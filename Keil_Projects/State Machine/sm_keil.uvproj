# Keil uVision project sm_keil.uvproj, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2294 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: sm_keil
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c state_machine.c LED.c
