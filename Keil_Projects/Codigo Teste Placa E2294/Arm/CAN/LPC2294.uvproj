# Keil uVision project LPC2294.uvproj, settings and files
target ARM (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LPC2294 +hex
  c flags: Optim=1
  c include: ..\CAN
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Init Hardware
    ./: Startup.s
  group Source Codes
    ./: global.c main.c init.c
